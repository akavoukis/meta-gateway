FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

COMPATIBLE = "raspberrypi2"
